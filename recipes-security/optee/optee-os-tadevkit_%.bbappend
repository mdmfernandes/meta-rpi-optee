require optee-os-rpi.inc

# OPTEE is compatible with our machine
COMPATIBLE_MACHINE = "raspberrypi4-64-optee"
