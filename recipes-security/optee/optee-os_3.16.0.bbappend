# Tell OPTEE that this machine is compatible
COMPATIBLE_MACHINE = "raspberrypi4-64-optee"
