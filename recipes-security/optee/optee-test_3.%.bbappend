# OPTEE is compatible with our machine
COMPATIBLE_MACHINE = "raspberrypi4-64-optee"

# 3.19.0
SRCREV = "ab9863cc187724e54c032b738c28bd6e9460a4db"
