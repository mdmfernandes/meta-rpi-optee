# OPTEE is compatible with our machine
COMPATIBLE_MACHINE:raspberrypi4-64-optee = "raspberrypi4-64-optee"
