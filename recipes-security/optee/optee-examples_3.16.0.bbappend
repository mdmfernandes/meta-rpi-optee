# 4.3.0.
SRCREV = "378dc0db2d5dd279f58a3b6cb3f78ffd6b165035"

SRC_URI = "git://github.com/linaro-swg/optee_examples.git;branch=master;protocol=https"
