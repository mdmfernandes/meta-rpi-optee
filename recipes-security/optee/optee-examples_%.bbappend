COMPATIBLE_MACHINE:raspberrypi4-64-optee = "raspberrypi4-64-optee"
